# Keil uVision project mm32f527x_e9p.uvprojx, settings and files
target mm32f527x_e9p_project (6180000::V6.18::ARMCLANG)
  device: MM32F5277E9PV MindMotion
  pack: MindMotion.MM32F5277E_DFP.0.0.8
  cpu: IRAM(0x30000000,0x1C000) IROM(0x08000000,0x40000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: mm32f527x_e9p
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DCACHE_DISABLED CFG_TUSB_MCU NDEBUG
  c include: ..\include;..\..\libraries\zf_common;..\..\libraries\zf_device;..\..\libraries\zf_driver;..\..\libraries\sdk;..\..\libraries\sdk\CMSIS\Include;..\..\libraries\sdk\CMSIS\DSP\Include;..\..\libraries\sdk\CMSIS\DSP\Include\dsp;..\..\libraries\sdk\drivers;..\..\libraries\components\ff14b\source;..\..\libraries\components\tinyusb\src;..\..\libraries\components\tinyusb\src\class\audio;..\..\libraries\components\tinyusb\src\class\bth;..\..\libraries\components\tinyusb\src\class\cdc;..\..\libraries\components\tinyusb\src\class\dfu;..\..\libraries\components\tinyusb\src\class\hid;..\..\libraries\components\tinyusb\src\class\midi;..\..\libraries\components\tinyusb\src\class\msc;..\..\libraries\components\tinyusb\src\class\net;..\..\libraries\components\tinyusb\src\class\usbtmc;..\..\libraries\components\tinyusb\src\class\vendor;..\..\libraries\components\tinyusb\src\class\video;..\..\libraries\components\tinyusb\src\common;..\..\libraries\components\tinyusb\src\device;..\..\libraries\components\tinyusb\src\host;..\..\libraries\components\tinyusb\src\osal;..\..\libraries\components\freertos\FreeRTOS-Kernel\include;..\..\libraries\components\freertos\FreeRTOS-Kernel\portable\GCC\ARM_CM33_NTZ\non_secure
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x1c000
  scatter file: ..\..\libraries\sdk\mdk\linker\mm32f5277e_flash.scf
  group src
    ../src/: isr.c main.c share_ware.c freertos_task.c
  group src/driver
    ../src/driver/: uart.c dma.c
  group src/control
    ../src/control/: filter.c kinematics.c velocity.c pid.c motor.c
  group src/sensor
    ../src/sensor/: encoder.c
  group zf_common
    ../../libraries/zf_common/: zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_headfile.h zf_common_interrupt.c zf_common_interrupt.h zf_common_typedef.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_can.c zf_driver_can.h zf_driver_dac.c zf_driver_dac.h zf_driver_delay.c zf_driver_delay.h zf_driver_dma.c zf_driver_dma.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_flash.c zf_driver_flash.h zf_driver_fsmc.c zf_driver_fsmc.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_iic.c zf_driver_iic.h zf_driver_iis.c zf_driver_iis.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_soft_spi.c zf_driver_soft_spi.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h
  group zf_device
    ../../libraries/zf_device/: zf_device_absolute_encoder.c zf_device_absolute_encoder.h zf_device_bluetooth_ch9141.c zf_device_bluetooth_ch9141.h zf_device_camera.c zf_device_camera.h zf_device_config.h zf_device_config.lib zf_device_dl1a.c zf_device_dl1a.h zf_device_dm1xa.c zf_device_dm1xa.h zf_device_gps_tau1201.c zf_device_gps_tau1201.h zf_device_gt911.c zf_device_gt911.h zf_device_icm20602.c zf_device_icm20602.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_ips114.c zf_device_ips114.h zf_device_ips200.c zf_device_ips200.h zf_device_ips350.c zf_device_ips350.h zf_device_is66wv51216.c zf_device_is66wv51216.h zf_device_k24c02.c zf_device_k24c02.h zf_device_key.c zf_device_key.h zf_device_mpu6050.c zf_device_mpu6050.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_oled.c zf_device_oled.h zf_device_ov7725.c zf_device_ov7725.h zf_device_scc8660.c zf_device_scc8660.h zf_device_tft180.c zf_device_tft180.h zf_device_type.c zf_device_type.h zf_device_virtual_oscilloscope.c zf_device_virtual_oscilloscope.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_wireless_uart.c zf_device_wireless_uart.h
  group sdk
    ../../libraries/sdk/mdk/: startup_mm32f5277e.S
    ../../libraries/sdk/: hal_device_registers.h mm32f5277e.h mm32f5277e_features.h system_mm32f5277e.c system_mm32f5277e.h
    ../../libraries/sdk/drivers/: hal_adc.c hal_adc.h hal_common.h hal_comp.c hal_comp.h hal_cordic.c hal_cordic.h hal_crc.c hal_crc.h hal_dac.c hal_dac.h hal_dma.c hal_dma.h hal_dma_request.h hal_enet.c hal_enet.h hal_exti.c hal_exti.h hal_flexcan.c hal_flexcan.h hal_fsmc.c hal_fsmc.h hal_gpio.c hal_gpio.h hal_i2c.c hal_i2c.h hal_i2s.c hal_i2s.h hal_iwdg.c hal_iwdg.h hal_lptim.c hal_lptim.h hal_lpuart.c hal_lpuart.h hal_mds.c hal_mds.h hal_mds_remap.h hal_power.c hal_power.h hal_pwr.c hal_pwr.h hal_qspi.c hal_qspi.h hal_rcc.c hal_rcc.h hal_rtc.c hal_rtc.h hal_spi.c hal_spi.h hal_syscfg.c hal_syscfg.h hal_tim.c hal_tim.h hal_uart.c hal_uart.h hal_usb.c hal_usb.h hal_usb_bdt.h hal_wwdg.c hal_wwdg.h
  group freeRTOS
    ../../libraries/components/freertos/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../libraries/components/freertos/FreeRTOS-Kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c portasm.h portmacro.h
    ../../libraries/components/freertos/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../../libraries/components/freertos/FreeRTOS-Kernel/include/: FreeRTOSConfig.h
